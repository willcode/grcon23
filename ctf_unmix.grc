options:
  parameters:
    generate_options: no_gui
    id: ctf_unmix
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_add_xx_4
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_rotator_cc_0_2
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-3.14159 / 4'
  states: {}
- name: blocks_rotator_cc_0_2_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 3.14159 / 4
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_2
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_2_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_sink_4
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: out1.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_sink_5
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: out2.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_sink_6
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: out3.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_sink_7
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: out4.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_4
  id: blocks_wavfile_source
  parameters:
    file: Signal.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2000'
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2000'
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2000'
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2000'
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}

connections:
- [blocks_add_xx_4, '0', low_pass_filter_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_sub_xx_2, '0']
- [blocks_complex_to_real_0_0, '0', blocks_sub_xx_2_0, '0']
- [blocks_float_to_complex_0, '0', blocks_rotator_cc_0_2, '0']
- [blocks_float_to_complex_0, '0', blocks_rotator_cc_0_2_0, '0']
- [blocks_rotator_cc_0_2, '0', blocks_complex_to_real_0, '0']
- [blocks_rotator_cc_0_2_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_sub_xx_1, '0', low_pass_filter_0_0_0, '0']
- [blocks_sub_xx_2, '0', low_pass_filter_0_0_0_0_0, '0']
- [blocks_sub_xx_2_0, '0', low_pass_filter_0_0_0_0, '0']
- [blocks_wavfile_source_4, '0', blocks_add_xx_4, '0']
- [blocks_wavfile_source_4, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_4, '0', blocks_sub_xx_1, '0']
- [blocks_wavfile_source_4, '0', blocks_sub_xx_2, '1']
- [blocks_wavfile_source_4, '1', blocks_add_xx_4, '1']
- [blocks_wavfile_source_4, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_4, '1', blocks_sub_xx_1, '1']
- [blocks_wavfile_source_4, '1', blocks_sub_xx_2_0, '1']
- [low_pass_filter_0_0, '0', blocks_wavfile_sink_4, '0']
- [low_pass_filter_0_0_0, '0', blocks_wavfile_sink_5, '0']
- [low_pass_filter_0_0_0_0, '0', blocks_wavfile_sink_7, '0']
- [low_pass_filter_0_0_0_0_0, '0', blocks_wavfile_sink_6, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
