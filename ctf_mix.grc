options:
  parameters:
    generate_options: no_gui
    id: ctf_mix
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_3
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 3.14159 / 4
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-3.14159 / 4'
  states: {}
- name: blocks_rotator_cc_0_1
  id: blocks_rotator_cc
  parameters:
    phase_inc: '0'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_sink_3
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: Signal.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: Flag1.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: Flag2.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_2
  id: blocks_wavfile_source
  parameters:
    file: Flag3.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_3
  id: blocks_wavfile_source
  parameters:
    file: Flag4.wav
    repeat: 'False'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_add_xx_1, '0']
- [blocks_add_xx_0, '0', blocks_float_to_complex_1, '0']
- [blocks_add_xx_1, '0', blocks_float_to_complex_1_0, '0']
- [blocks_add_xx_2, '0', blocks_float_to_complex_1_1, '0']
- [blocks_add_xx_3, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_3, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_3, '1']
- [blocks_float_to_complex_1, '0', blocks_rotator_cc_0_1, '0']
- [blocks_float_to_complex_1_0, '0', blocks_rotator_cc_0, '0']
- [blocks_float_to_complex_1_1, '0', blocks_rotator_cc_0_0, '0']
- [blocks_rotator_cc_0, '0', blocks_add_xx_3, '1']
- [blocks_rotator_cc_0_0, '0', blocks_add_xx_3, '0']
- [blocks_rotator_cc_0_1, '0', blocks_add_xx_3, '2']
- [blocks_sub_xx_0, '0', blocks_add_xx_2, '0']
- [blocks_sub_xx_0, '0', blocks_float_to_complex_1, '1']
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_sub_xx_0, '0']
- [blocks_wavfile_source_1, '0', blocks_add_xx_0, '1']
- [blocks_wavfile_source_1, '0', blocks_sub_xx_0, '1']
- [blocks_wavfile_source_2, '0', blocks_add_xx_1, '1']
- [blocks_wavfile_source_3, '0', blocks_add_xx_2, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
