options:
  parameters:
    generate_options: no_gui
    id: ctf_c2_gen
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: xlate_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '3000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: '.01'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 3.14159/4
  states: {}
- name: blocks_rotator_cc_0_1
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-3.14159/4'
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    center_freq: np.nan
    filename: C2_Signal
    sample_rate: samp_rate
    type: complex float (fc32_le)
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C2_out.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/jwl/gnuradio/ctf2023/C2_Flags_Stereo.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_0_1
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '8000'
    decim: '1'
    samp_rate: samp_rate
    taps: xlate_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-4000'
    decim: '1'
    samp_rate: samp_rate
    taps: xlate_taps
    type: ccc
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}

connections:
- [analog_noise_source_x_1, '0', blocks_add_xx_1, '2']
- [blocks_add_xx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_add_xx_1, '0', blocks_sigmf_sink_minimal_0, '0']
- [blocks_add_xx_1, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_add_xx_1, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [blocks_complex_to_float_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_add_xx_0, '1']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_xx_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_rotator_cc_0, '0', blocks_add_xx_1, '1']
- [blocks_rotator_cc_0_1, '0', blocks_add_xx_1, '0']
- [blocks_wavfile_source_0, '0', hilbert_fc_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_rotator_cc_0, '0']
- [filter_fft_low_pass_filter_0_1, '0', blocks_rotator_cc_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '0']
- [hilbert_fc_0, '0', filter_fft_low_pass_filter_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
